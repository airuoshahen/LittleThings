# IAR project test.ewp, settings and files
configuration test (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0B1RE ST STM32G0B1RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G0B1xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ..\..\..\FreeRTOS\include; ..\..\..\FreeRTOS\portable\IAR\ARM_CM0; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: test.hex
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: stm32g0b1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ./: FreeRTOSConfig.h
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c
  group FreeRTOS/Port
    ../../../FreeRTOS/portable/MemMang/: heap_2.c
    ../../../FreeRTOS/portable/IAR/ARM_CM0/: port.c portasm.s
  group FreeRTOS/Src
    ../../../FreeRTOS/: list.c queue.c tasks.c timers.c
